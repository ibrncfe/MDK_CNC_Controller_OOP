# Keil uVision project CNC_2Axis_SARMAT.uvprojx, settings and files
target CNC_2Axis_SARMAT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CNC_2Axis_SARMAT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers;..\Drivers\Components;..\Drivers\STM32F4xx_Nucleo;..\Drivers\X_NUCLEO_PLC01A1;..\Drivers\Components\Common;..\Drivers\Components\CLT01_38SQ7;..\Drivers\Components\VNI8200XP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: ILI9225.c pioneer.c main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c rnk.c
  group Drivers/BSP/Components
    ../Drivers/Components/VNI8200XP/: vni8200xp.c
    ../Drivers/Components/CLT01_38SQ7/: clt01_38s.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../Drivers/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_PLC01A1
    ../Drivers/X_NUCLEO_PLC01A1/: x_nucleo_plc01a1.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
